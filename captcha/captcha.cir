* spice captcha
R1 1 0 42
.end
